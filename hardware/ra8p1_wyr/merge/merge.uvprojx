# Keil uVision project merge.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: R7KA8P1KF:CPU0 Renesas
  pack: Renesas.RA_DFP.6.4.0
  cpu: IRAM(0x22000000,0x1A0000) IRAM2(0x0,0x20000) IROM(0x02000000,0x00100000) XRAM(0x20000000,0x20000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: merge +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundleandpartition --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  AfterMake: cmd /c "python "$Pscripts\strip_code_hex.py" "$PObjects\merge.hex" "$PObjects\merge_code.hex" && copy /Y "$PObjects\merge_code.hex" "$PObjects\merge.hex" && python "$Pscripts\patch_merge_rpd.py" "$PObjects\merge.rpd""
  c flags: v6Lang=3 v6LangP=6
  c misc: @./via/rasc_armclang.via
  asm misc: --via=./via/rasc_armasm.via
  memory RVCT4: ROM 0x2000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x22000000 size 0x1a0000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\script\fsp.scat
  link misc: --via=./via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: Actuator_Comm_Task_entry.c app_startup.c app_startup.h adc_shared.c adc_shared.h dev_tds_driver.c dev_tds_driver.h ds18b20.c ds18b20.h fault_debug.c hal_warmstart.c pump_drv8870.c pump_drv8870.h sensor_fusion.c sensor_fusion.h Sensor_Task_entry.c sht30.c sht30.h soil_moisture_adc.c soil_moisture_adc.h ch340_host.c ch340_host.h usb_app.c usb_app.h usb_light.c usb_light.h USB_Light_Task_entry.c
software components: Flex Software:RA Configuration 1.0.0
