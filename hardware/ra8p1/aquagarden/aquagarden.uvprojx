# Keil uVision project aquagarden.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: R7KA8P1KF:CPU0 Renesas
  pack: Renesas.RA_DFP.6.4.0
  cpu: IRAM(0x22000000,0x1A0000) IRAM2(0x0,0x20000) IROM(0x02000000,0x00100000) XRAM(0x20000000,0x20000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: aquagarden +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=6
  c misc: @./via/rasc_armclang.via
  asm misc: --via=./via/rasc_armasm.via
  memory RVCT4: ROM 0x2000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x22000000 size 0x1a0000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\script\fsp.scat
  link misc: --via=./via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_warmstart.c main_service_entry.c new_thread0_entry.c.bak sensor_app_entry.c.bak
  group AquaGarden Device
    ./device/: dev_adc_shared.c dev_atomizer_driver.c dev_ds18b20_driver.c dev_pump_driver.c dev_sht30_driver.c dev_soil_humid_sen_driver.c dev_tds_driver.c dev_usb_light_driver.c
  group AquaGarden Module
    ./module/: aquagarden_app.c sensor_fusion.c com_protocol.c com_service.c
software components: Flex Software:RA Configuration 1.0.0
