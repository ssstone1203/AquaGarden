# Keil uVision project FSP_text.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: R7FA0E107 Renesas
  pack: Renesas.RA_DFP.6.1.0
  cpu: CPUTYPE("Cortex-M23")      CLOCK(12000000) ELITTLE
  output: FSP_text +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: Optim=1 v6Lang=3 v6LangP=6 wLevel=1
  c misc: @via/rasc_armclang.via
  asm misc: --via=via/rasc_armasm.via
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c hal_warmstart.c
software components: Flex Software:RA Configuration 1.0.0
