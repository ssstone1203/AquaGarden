# Keil uVision project pressure_sensor_freertos.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: R7FA6E2BB Renesas
  pack: Renesas.RA_DFP.6.1.0
  cpu: IRAM(0x20000000,0xA000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: pressure_sensor_freertos +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=6
  c misc: @via/rasc_armclang.via
  asm misc: --via=via/rasc_armasm.via
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via
  group Source Group 1
    D:/FreeRTOS-Kernel-main/FreeRTOS-Kernel-main/portable/MemMang/: heap_4.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_warmstart.c new_thread0_entry.c.bak pressure_thread_entry.c pressure_sensor.c pressure_sensor.h
software components: Flex Software:RA Configuration 1.0.0
